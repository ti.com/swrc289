# Allegro board CC3200-LAUNCHXL_BRD_Rev4p1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CC_GPIO_22: length 72.9
  TOP w0.152: U13.15 21.52,31.29 19.56,29.34 v1(19.18,29.34) ; SW2.1 44.33,2.58 R128.1 43.79,2.57 43.43,2.92 43.43,17.14 45.21,18.92 ; 45.21,18.92 44.58,19.56 v1(44.58,25.15) ; 45.21,18.92 53.31,18.92 55.34,20.95 R109.2
  BOTTOM w0.152: v1(19.18,29.34) 19.3,29.21 19.3,28.45 23.14,24.61 31.2,24.61 31.64,24.18 43.61,24.18 v1(44.58,25.15)
CC_GPIO_23: length 69.6
  TOP w0.152: R104.1 45.72,23.59 v1(45.72,23.37) ; v1(14.48,28.19) 14.61,28.32 17.17,28.32 17.65,28.8 19.66,28.8 21.65,30.79 U13.16
  PWR w0.152: v1(14.48,28.19) 14.39,28.19 12.06,30.52 12.06,41.4 13.21,42.55 13.21,45.2 17.14,49.14 J10.2
  BOTTOM w0.152: v1(14.48,28.19) 14.61,28.32 15.88,28.32 21.97,22.23 44.58,22.23 v1(45.72,23.37)
CC_GPIO_24: length 88.2
  TOP w0.152: U13.17 21.66,30.04 19.95,28.33 17.69,28.33 17.17,27.81 v1(15.11,27.81) ; R108.1 v1(45.47,21.59) ; R74.1 v1(45.47,39.37)
  PWR w0.152: J11.2 16,46.99 16,41.02 13.56,38.58 13.56,30.51 14.48,29.59 14.48,29.55 14.48,28.96 15.11,28.32 v1(15.11,27.81) ; v1(45.47,21.59) 46.48,22.61 46.48,38.35 v1(45.47,39.37)
  BOTTOM w0.152: v1(15.11,27.81) 21.84,21.08 31.19,21.08 31.7,21.59 v1(45.47,21.59)
CC_GPIO_26: length 88.6
  TOP w0.152: U13.29 28.79,29.43 28.5,29.14 27.87,29.14 v1(27.81,29.08) ; v1(42.29,47.62) 43.81,47.62 44.83,46.61 44.83,45.21 45.59,44.45 R66.1 46.26,43.69 46.51,43.43 v1(47.24,43.43)
  BOTTOM w0.152: J5.3 3.94,54.86 3.94,54.23 10.92,47.24 18.29,47.24 19.02,47.98 41.94,47.98 v1(42.29,47.62) ; v1(47.24,43.43) 47.19,43.38 47.19,31.69 46.39,30.89 37.35,30.89 37.06,30.89 35.28,32.66 32.41,32.66 31.5,31.75 31.5,31.07 31.24,30.81 28.55,28.12 28.08,28.12 27.79,28.42 27.79,29.06 v1(27.81,29.08)
CC_GPIO_27: length 88.5
  TOP w0.152: R68.1 v1(45.47,41.91) ; v1(28.29,28.63) 28.65,28.63 29.28,29.27 29.28,29.43 29.29,29.43 U13.30
  PWR w0.152: v1(45.21,47.12) 45.97,46.35 45.97,42.42 v1(45.47,41.91) 44.7,41.15 44.7,39.19 46.1,37.79 46.1,32.28 45.21,31.39 v1(44.58,31.39)
  BOTTOM w0.152: v1(45.21,47.12) 44.2,48.13 42.59,48.13 42.08,48.64 10.39,48.64 4.57,54.46 4.57,56.9 3.17,58.29 J5.4 ; v1(28.29,28.63) 28.56,28.63 30.47,30.54 31.14,31.21 31.14,31.9 32.26,33.02 35.43,33.02 37.21,31.24 44.42,31.24 v1(44.58,31.39)
CC_GPIO_28: length 54.5
  TOP w0.152: v1(45.47,32.64) 45.97,32.64 46.26,32.36 R88.1 ; v1(44.07,43.18) 44.32,42.93 54.99,42.93 55.34,42.57 R69.2 ; v1(22.1,29.46) 22.28,29.28 23.06,29.28 23.29,29.52 U13.18
  PWR w0.152: v1(45.47,32.64) 43.56,34.54 43.56,42.67 v1(44.07,43.18)
  BOTTOM w0.152: v1(22.1,29.46) 22.58,29.95 28.87,29.95 30.43,31.51 30.43,32.21 33.6,35.38 35.48,35.38 38.23,32.64 v1(45.47,32.64)
CC_GPIO_30: length 26.2
  TOP w0.152: v1(28.35,40.51) 28.29,40.45 U13.53 ; R99.2 v1(14.48,25.65)
  PWR w0.152: v1(28.35,40.51) 27.34,39.5 23.5,39.5 22.1,38.1 22.1,31.5 16.26,25.65 v1(14.48,25.65)
CC_GPIO_31: length 21.1
  TOP w0.152: R65.2 41.43,45.44 42.11,44.76 42.11,40.92 44.42,38.61 48.01,38.61 48.64,37.97 54.74,37.97 55.34,37.37 R80.2
CC_NRESET: length 109.1
  TOP w0.152: U13.32 30.29,29.43 31.27,28.46 31.28,28.46 31.75,27.99 31.75,26.82 C46.1 32.4,25.03 32.41,25.02 32.41,23.78 v1(32.54,23.65) ; Q1.1 48.65,90.41 50.08,88.99 SW1.2 49.7,83.44 R129.2 47.22,83 46.99,82.78 46.58,82.78 46.26,82.45 R5.2 46.29,82.01 D3.2 46.29,79.44 47.37,78.36 53.98,78.36 57.28,75.06 57.28,50.04 56.52,49.28 43.18,49.28 v1(42.67,48.77)
  PWR w0.152: v1(32.54,23.65) 32.58,23.69 37.78,23.69 42.82,28.73 42.82,48.62 v1(42.67,48.77)
DBG_RST_N: length 15.7
  TOP w0.152: v1(11.43,72.52) 12.05,71.89 13.83,71.89 14.07,72.13 R30.2 14.96,73.41 U5.19 ; v1(12.45,66.17) 12.45,65.98 11.48,65.01 U9.10
  BOTTOM w0.152: v1(11.43,72.52) 12.19,71.75 12.19,66.42 v1(12.45,66.17)
DBGENN: length 25.7
  TOP w0.152: R28.2 12.45,73.53 11.53,74.45 R22.2 11.53,76.36 11.18,76.71 8.51,76.71 8,77.22 8,78.87 8.24,79.11 8.26,79.11 ; 6.42,79.76 6.81,79.36 8,79.36 8.26,79.11 ; 6.42,79.76 U4.4 ; 6.42,79.76 7.72,81.06 ; 8.26,79.11 U4.10 ; U4.1 6.47,81.71 6.77,82 ; 7.72,81.06 6.77,82 ; 7.72,81.06 U4.13 ; 6.77,82 R4.2
DBGMOD: length 16
  TOP w0.152: v1(10.79,77.22) 11.68,77.22 12.12,76.78 12.12,75.01 12.45,74.68 R26.2 ; U4.2 v1(5.3,81.06) ; U4.5 5.86,79.11 v1(6.1,78.87)
  BOTTOM w0.152: v1(10.79,77.22) 7.75,77.22 v1(6.1,78.87) 6.1,80.26 v1(5.3,81.06)
FL_SWN: length 8.4
  TOP w0.254: 32.38,38.71 32.38,37.98 31.7,37.29 U13.46
  TOP w0.381: 32.38,38.71 32.38,38.95 34.59,41.16 34.59,41.72 35.49,42.62 35.51,42.62 L4.1
FL_SWP: length 13.9
  TOP w0.203: R65.1 39.09,43.18 L4.2
  TOP w0.254: 33.05,38.76 32.91,38.62 32.91,37.84 31.86,36.79 U13.45
  TOP w0.381: L4.2 38.12,43.16 38.12,42.31 37.85,42.04 35.73,42.04 35.18,41.48 35.18,40.89 33.05,38.76
FT_CS: length 15
  TOP w0.152: U9.5 5.45,65.01 6.1,65.66 v1(6.1,68.2) ; v1(11.18,70.23) 11.18,70.36 10.95,70.58 U7.9 ; R34.2 11.72,71.25 v1(11.58,71.39)
  BOTTOM w0.152: v1(11.58,71.39) 11.58,70.63 v1(11.18,70.23) 9.14,68.2 v1(6.1,68.2)
FT_DI: length 13.5
  TOP w0.152: U9.11 8.38,65.66 7.49,66.55 7.49,70.87 8.51,71.88 U7.11 10.79,71.88 11.05,71.63 11.05,71.2 12.02,70.23 R36.2
FT_DO: length 27.5
  TOP w0.152: v1(7.37,78.49) 6.73,78.49 2.79,74.55 2.79,73.33 2.95,73.18 U7.2 ; U4.9 10.77,78.46 v1(11.05,78.74) ; v1(13.34,67.94) 13.46,68.07 R41.2
  BOTTOM w0.152: v1(7.37,78.49) 7.62,78.74 v1(11.05,78.74) 11.68,78.11 11.68,76.39 14.1,73.98 14.1,68.71 v1(13.34,67.94)
FT_SK: length 20.1
  TOP w0.152: R46.2 13.59,66.93 v1(13.46,67.06) ; v1(8,80.26) 8.14,80.41 U4.12
  BOTTOM w0.152: v1(8,80.26) 10.24,80.26 12.04,78.47 12.04,76.54 14.45,74.13 14.45,68.05 v1(13.46,67.06)
FTDI_RX: length 6.9
  TOP w0.152: R53.2 26.54,67.69 27.53,68.68 R40.2
FTDI_TX: length 12.9
  TOP w0.152: R35.2 27.94,70.61 28.19,70.36 28.19,67.82 v1(27.81,67.44) ; U11.4 v1(21.67,62.06)
  BOTTOM w0.152: v1(21.67,62.06) 22.44,62.06 v1(27.81,67.44)
LP_GPIO_01: length 53.7
  TOP w0.152: v1(42.14,49.33) 42.14,48.54 42.42,48.26 53.21,48.26 57.84,43.64 57.84,25.96 56.01,24.13 R105.2
  BOTTOM w0.152: v1(42.14,49.33) 42.06,49.4 33.78,49.4 32.51,50.67 J7.1
LP_GPIO_02: length 20.4
  TOP w0.152: R70.2 v1(14.48,41.4)
  PWR w0.152: J6.1 24.77,51.82 19.18,51.82 18.41,51.05 18.41,49.91 15.37,46.86 15.37,42.29 v1(14.48,41.4)
LP_GPIO_25: length 41
  TOP w0.152: v1(45.47,34.54) 45.72,34.29 R83.1 46.26,34.83 46.48,35.05 48.26,35.05 48.77,35.56 52.7,35.56 53.21,36.07 56.9,36.07 57.48,35.48 57.48,28.14 56.01,26.67 R98.2
  PWR w0.152: v1(45.47,34.54) 44.89,35.12 44.89,38.5 44.35,39.04 44.35,42.74 44.7,43.1 44.7,48.9 J14.1
LP_RESET_OUT: length 57.2
  TOP w0.152: R287.2 54.38,35.08 54.58,34.88 54.91,34.88 54.94,34.84 55.94,34.84 56.13,34.65 v1(56.13,34.29) R84.2 ; v1(53.09,80.01) 52.42,80.68 D3.1
  BOTTOM w0.152: v1(53.09,80.01) 57.28,75.82 57.28,35.43 v1(56.13,34.29)
PA_SWN: length 10.5
  TOP w0.254: 37.59,37.02 36.58,37.02 35.61,36.04 33.69,36.04 32.44,34.79 U13.41
  TOP w0.505: L6.1 39.15,36.84 38.98,37.02 37.59,37.02
PA_SWP: length 6.5
  TOP w0.254: U13.40 32.59,34.29 33.73,35.43 34.64,35.43
  TOP w0.505: L6.2 34.64,35.43
SENS_I2C_SCL: length 12.8
  TOP w0.152: J3.1 47.75,66.93 48.13,66.55 R47.2
  TOP w0.203: R48.1 R47.2 50.07,67.85 50.67,68.45 52.45,68.45 53.03,69.03 R39.1
SENS_I2C_SDA: length 22.1
  TOP w0.152: R55.1 49.81,62.68 R54.2 49.76,63.22 49.6,63.37 48.9,63.37 46.61,65.66 43.22,65.66 42.8,66.08 42.8,68.45 J2.1 46.86,69.47 47.5,68.83 50.55,68.83 51.14,69.43 R38.1
SFL_CLK: length 15.7
  TOP w0.152: 17.02,33.15 17.4,33.53 17.4,35.69 18.19,36.48 R132.1 15.65,37.21 15.49,37.06 U15.6 ; 17.02,33.15 U14.6 ; 17.02,33.15 17.53,33.15 18.02,32.66 18.9,32.66 19.46,32.11 20.17,32.11 21.36,33.29 U13.11
SFL_CS: length 20.1
  TOP w0.152: R130.2 12.04,31.02 12.09,30.96 12.95,30.96 12.95,29.59 13.59,28.96 13.92,28.96 14.17,28.7 16.89,28.7 18.03,29.84 19.56,29.84 21.51,31.79 U13.14
  TOP w0.203: R130.2 10.64,31.02 10.41,31.24 10.41,33.02 11.71,34.32 12.79,34.32 12.96,34.15 13.4,34.15
SFL_DIN: length 17.4
  TOP w0.152: U13.13 21.5,32.29 19.44,30.23 17.91,30.23 16.74,29.06 14.32,29.06 13.89,29.49
  TOP w0.203: v1(12.57,33.78) 12.7,33.65 13.4,33.65 ; v1(13.86,29.49) 13.97,29.49 14.22,29.74 14.22,30.96
  BOTTOM w0.152: v1(13.86,29.49) 13.76,29.59 13.72,29.59 12.19,31.11 12.19,33.4 v1(12.57,33.78)
SFL_DOUT: length 11.4
  TOP w0.152: U15.5 16.76,34.52 v1(16.81,34.48) ; U14.5 16.5,32.65 v1(16.64,32.51) 17.14,32.51 17.35,32.31 18.56,32.31 19.28,31.6 R131.1 19.68,31.11 21.36,32.79 U13.12
  BOTTOM w0.152: v1(16.81,34.48) 17.02,34.27 17.02,32.89 v1(16.64,32.51)
SOP0: length 49.1
  TOP w0.152: R59.1 56.52,51.82 J17.1 ; U13.35 31.96,31.79 32,31.75 32.03,31.75 v1(32.14,31.64)
  BOTTOM w0.152: v1(32.14,31.64) 32.56,31.22 35.08,31.22 35.76,30.53 36.91,30.53 46.54,30.53 46.75,30.74 47.98,31.97 47.98,46.2 51.56,49.78 51.56,51.44 52.07,51.94 54.1,51.94 J17.1
SOP1: length 44.8
  TOP w0.152: v1(32.13,30.86) 31.7,31.29 U13.34 ; R58.1 54.1,55.65 54.1,51.94 J16.1
  BOTTOM w0.152: v1(32.13,30.86) 34.93,30.86 35.62,30.18 37.65,30.18 46.69,30.18 47.1,30.59 48.41,31.9 48.41,45.36 52.83,49.78 J16.1
SOP2: length 8.5
  TOP w0.152: J15.1 49.02,51.94 49.02,54.25 47.6,55.68 46.74,55.68 R61.1 46.63,55.78 R60.1
SRSTN: length 50
  TOP w0.152: R129.1 45.72,83.44 45.34,83.06 45.34,79.12 44.45,78.23 39.5,78.23 32.38,71.12 32.38,65.91 27.56,61.09 21.02,61.09 20.56,60.63 19.71,60.63 19.05,61.29 19.05,61.85 17.78,63.12 R52.2
N24159: length 6.6
  TOP w0.203: 34.92,33.27 32.88,33.27 32.86,33.29 U13.38
  TOP w0.505: 34.92,33.27 35.31,33.27 35.98,32.6 L7.2
N24403: length 8.6
  TOP w0.254: U13.43 32.15,35.79 33.31,36.96 35.05,36.96 35.38,37.29
  TOP w0.505: 35.38,37.29 35.43,37.34 35.43,38.73 36.49,39.79 L5.2
N27756: length 5.2
  TOP w0.254: U13.31 29.79,29.26
  TOP w0.305: 29.79,25.2 FL1.1
  TOP w0.457: 29.79,29.26 29.79,25.2
N28553: length 7.2
  TOP w0.152: U13.51 29.31,39.06 29.31,44.58 Y2.1 29.43,44.94 C25.1
N28565: length 8.8
  TOP w0.152: U13.52 28.79,40.1 28.96,40.26 28.96,42.48 27.91,43.53 26.84,43.53 26.69,43.68 Y2.2 26.58,44.81 C26.1
N30169: length 6.5
  TOP w0.152: U13.22 25.29,28.99 24.76,28.45 24,28.45 23.11,27.56 23.11,27.15 Y3.3 22.08,26.76 C47.1
N36298: length 41.3
  TOP w0.152: v1(11.43,26.29) 16.81,26.29 18.15,27.62 20.52,27.62 20.89,27.99 22.78,27.99 24.29,29.51 U13.20
  PWR w0.152: v1(11.43,26.29) 11.94,26.8 11.94,28.15 10.92,29.17 10.92,42.67 11.43,43.18 11.43,47.5 J9.2
N36324: length 37.9
  TOP w0.152: v1(11.43,27.94) 11.81,27.56 14.65,27.56 14.9,27.3 17.16,27.3 17.83,27.98 20.37,27.98 20.74,28.35 22.63,28.35 23.79,29.51 U13.19
  PWR w0.152: J8.2 11.05,49.66 11.05,43.43 10.41,42.8 10.41,28.96 v1(11.43,27.94)
N49988: length 7.6
  TOP w0.505: J15.2 J16.2 R57.2
  BOTTOM w0.505: J17.2 J16.2
N54209: length 2.1
  TOP w0.152: J22.3 R67.2
N54213: length 2.1
  TOP w0.152: J22.19 R106.2
N54217: length 2.1
  TOP w0.152: J22.5 R73.2
N54221: length 2.1
  TOP w0.152: J22.7 R78.2
N54244: length 2.1
  TOP w0.152: J22.15 R96.2
N54248: length 2.1
  TOP w0.152: J22.17 R102.2
N141545: length 3.3
  TOP w0.152: R101.2 24.92,24.16 Y3.1 23.98,25.02 C48.1
N178690: length 53.3
  TOP w0.152: U13.21 24.79,29.2 v1(24.54,28.96) ; R60.2 44.71,56.74 44.4,56.43 44.4,54.2 45.39,53.21 J14.2
  BOTTOM w0.152: v1(24.54,28.96) 25.18,29.59 29.02,29.59 30.78,31.36 30.78,32.04 32.12,33.38 35.58,33.38 35.78,33.17 36.82,32.13 46.1,32.13 46.74,32.77 46.74,48.51 47.62,49.4 47.62,52.07 J14.2
N185612: length 11.2
  TOP w0.152: C21.1 52.06,62.85 R288.1
  TOP w0.203: U10.3 53.46,62.98 C21.1 54.72,62.85 55.63,63.75 C17.1 54.72,65.3 54.3,65.71 U10.7 53.96,67.22 R43.1 R42.1
N185801: length 3
  TOP w0.203: R27.1 C11.1 54.24,72.53 53.98,72.27 U6.A3
N186121: length 2.6
  TOP w0.152: R51.2 51.08,63.95 R288.2
  TOP w0.203: R51.2 51.1,64.08 U10.1
N186159: length 2.4
  TOP w0.203: R42.2 51.98,67.3 51.98,65.41 52.24,65.15 U10.11
N186206: length 1.6
  TOP w0.203: U10.12 51.66,64.65 R48.2
N186210: length 4.2
  TOP w0.152: U10.2 52.96,63.61 52.78,63.42 v1(52.78,63.4) ; v1(51.56,61.7) 51.54,61.72 R55.2
  BOTTOM w0.152: v1(51.56,61.7) 52.25,61.7 52.78,62.23 v1(52.78,63.4)
N187169: length 3.2
  TOP w0.152: R31.2 R32.1
  TOP w0.203: R32.1 50.7,73.27 U6.C1
N187173: length 3
  TOP w0.203: U6.B1 R23.2 R24.1
N187525: length 2
  TOP w0.203: U6.B3 52.7,70.71 R39.2
N187543: length 2
  TOP w0.203: U6.C3 52.21,70.71 R38.2
N187584: length 4.2
  TOP w0.203: R37.1 50.24,70.23 50.67,70.23 51.31,70.87 51.31,72.3 51.78,72.77 U6.C2
N187626: length 15.5
  TOP w0.152: v1(54.86,64.52) 54.73,64.65 U10.5
  BOTTOM w0.152: v1(54.86,64.52) 53.72,65.66 42.55,65.66 J4.2
N192685: length 2.1
  TOP w0.152: J22.11 R87.2
N195183: length 1.7
  TOP w0.505: R20.2 31.99,78.44 D4.1
N195451: length 3.8
  TOP w0.152: U3.5 37,79.25 C6.2 35.66,79.24 R17.1 R18.2
N197053: length 5.4
  TOP w0.152: U13.23 25.79,28.95 25.02,28.18 25.02,25.5 R101.1
N224301: length 1.2
  TOP w0.457: R110.2 C49.1
N224305: length 5.2
  TOP w0.457: J18.1 36.62,18.25 36.61,18.25 L8.2 arc(34.77,19.79) 33.71,20.01 C49.2
N224377: length 4.2
  TOP w0.305: FL1.3 29.79,23.8
  TOP w0.457: 29.79,23.8 R111.1
N224405: length 4.1
  TOP w0.457: R111.2 J24.1
N233208: length 3.8
  TOP w0.152: R103.1 J22.18
N288081: length 2.3
  TOP w0.152: J23.16 R98.1
N288085: length 3.6
  TOP w0.152: J23.14 R93.1 R90.1
N288162: length 2.3
  TOP w0.152: J23.4 R69.1
N288174: length 2.3
  TOP w0.152: J23.10 R84.1
N288178: length 3.6
  TOP w0.152: J23.12 R89.1 R86.1
N288672: length 3.5
  TOP w0.152: R71.2 R68.2 J23.3
N288674: length 2.3
  TOP w0.152: J23.5 R74.2
N288676: length 4.3
  TOP w0.152: J23.7 R79.2 ; R79.2 R81.2 ; R79.2 R77.2
N288678: length 3.3
  TOP w0.152: R85.2 R83.2 J23.9
N288680: length 2.3
  TOP w0.152: R88.2 J23.11
N288682: length 2.3
  TOP w0.152: J23.13 R92.2
N288684: length 2.3
  TOP w0.152: R97.2 J23.15
N288686: length 2.3
  TOP w0.152: J23.17 R104.2
N288688: length 2.3
  TOP w0.152: J23.19 R108.2
N288796: length 3.3
  TOP w0.152: J23.1 R66.2 R63.2
N292143: length 5.6
  TOP w0.762: R112.1 54.22,12.72 Q2.3 54.23,12.58 53.09,11.43 J20.1
N314690: length 5.5
  TOP w0.152: J6.3 22.38,55.75 R56.1
N329065: length 1.2
  TOP w0.505: R115.2 56.24,10.53 Q2.1
N394921: length 1.6
  TOP w0.505: U8.5 41.88,73.03 42.16,73.03 42.37,73.23 L3.2
N412421: length 4.7
  TOP w0.152: R70.1 10.92,41.4 J22.6
N412425: length 5.2
  TOP w0.152: R72.1 12.19,40.13 J22.8
N439074: length 2.3
  TOP w0.152: J23.20 R109.1
N439968: length 3.8
  TOP w0.152: R107.1 J22.20
N454667: length 2.3
  TOP w0.152: R80.1 J23.8
N454954: length 6.6
  TOP w0.152: J22.10 10.41,35.81 10.41,37.21 12.06,38.86 R76.1
N454967: length 5.5
  TOP w0.152: R94.1 12.06,28.19 8.89,31.37 J22.12
N466203: length 2.1
  TOP w0.152: J22.9 R82.2
N466207: length 2.1
  TOP w0.152: J22.13 R91.2
N466247: length 4.8
  TOP w0.152: J22.14 11.18,26.92 R95.1
N466251: length 4.3
  TOP w0.152: R99.1 9.91,25.65 J22.16
N466300: length 2.3
  TOP w0.152: R75.1 J23.6
N466314: length 2.3
  TOP w0.152: R105.1 J23.18
N474715: length 5.1
  TOP w0.457: J24.2 L9.1
N487558: length 6.5
  TOP w0.254: R9.2 20.48,80.29 v1(20.7,80.52) ; 20.07,79.76 20.07,79.67 19.82,79.42 U5.7 ; R10.1 v1(22.61,81.92)
  TOP w0.4: 20.07,79.76 R9.2
  BOTTOM w0.254: v1(20.7,80.52) 21.21,80.52 v1(22.61,81.92)
N487570: length 3
  TOP w0.254: 20.57,79.25 20.32,78.99 U5.6
  TOP w0.505: C5.1 21.46,80.18 21.21,79.93 21.21,79.88 20.57,79.25
N487672: length 4.1
  TOP w0.254: U5.46 25.53,75.41 25.73,75.61
  TOP w0.505: R21.1 26.95,75.83 C8.1 25.94,75.82 25.73,75.61
N487804: length 3.4
  TOP w0.152: R10.2 21.31,78.99 21.09,78.99 20.82,78.72 U5.5
N487824: length 2
  TOP w0.152: R44.2 17.82,67.57 U5.26
N487832: length 2.7
  TOP w0.152: U5.10 18.32,79.22 17.78,79.76 R7.2
N487932: length 4
  TOP w0.152: R40.1 26.01,70.03 26.01,71.15 25.25,71.91 U5.39
N488104: length 3.5
  TOP w0.152: R35.1 26.57,71.22 25.38,72.41 U5.40
N488180: length 9.4
  TOP w0.152: v1(23.75,80.52) 23.24,80.01 23.24,78.99 22.82,78.57 U5.1 ; U2.2 26.73,80.55 R14.2 27.21,80.49 v1(27.3,80.39)
  BOTTOM w0.152: v1(27.3,80.39) 27.18,80.52 v1(23.75,80.52)
N488188: length 7.2
  TOP w0.152: U2.1 26.08,81.17 R13.2 24.86,80.49 24.19,79.82 U5.48
N488454: length 4.3
  TOP w0.152: R46.1 15.94,67.66 U5.24
N488458: length 4.6
  TOP w0.152: R41.1 15.21,68.58 14.77,69.02 14.77,71.18 15,71.41 U5.23
N488478: length 3.7
  TOP w0.152: R6.2 30.2,80.39 R12.1 29.05,80.8 28.03,81.83 U2.4
N488614: length 10.4
  TOP w0.152: v1(28.07,79.63) 28.1,79.66 R12.2 27.38,81.11 U2.3 ; U5.2 22.32,79.09 v1(22.61,79.38)
  BOTTOM w0.152: v1(22.61,79.38) 27.81,79.38 v1(28.07,79.63)
N488706: length 7.2
  TOP w0.152: Y1.1 30.09,73.71 27.46,73.71 C10.1 26.27,73.68 25.53,74.42 24.2,74.42 U5.44
N488714: length 6.2
  TOP w0.152: U5.43 25.28,73.91 26.56,72.63 C12.1 27.83,73.03 Y1.2
N489641: length 3.5
  TOP w0.152: U5.22 14.96,71.91 14.39,71.34 14.39,70.39 14.22,70.23 R36.1
N489651: length 2.7
  TOP w0.152: R34.1 14.1,71.65 14.2,71.65 14.95,72.41 U5.21
N490588: length 1.2
  TOP w0.381: 11.43,88.77 11.15,89.05 J1.1
N490592: length 3.1
  TOP w0.381: 8.26,88.65 8.55,88.94 J1.5
  TOP w0.505: L1.2 7.94,88.33 8.26,88.65
N490656: length 18.9
  TOP w0.4: R8.1 18.92,81.79 v1(19.05,81.92) ; v1(10.41,85.17) 10.2,85.38 U1.2 10.67,86.74 10.67,88.13 10.5,88.31 J1.2
  BOTTOM w0.4: v1(19.05,81.92) 19.14,81.82 19.14,81.28 18.72,80.85 11.96,80.85 10.19,82.62 10.19,84.94 v1(10.41,85.17)
N490660: length 21.3
  TOP w0.4: v1(19.94,81.92) 20.07,81.79 R9.1 ; J1.3 9.85,88.5 9.66,88.31 9.64,88.31 9.27,87.94 9.27,87.93 9.27,87.92 9.27,86.49 U1.1 9.5,85.4 v1(9.27,85.17)
  BOTTOM w0.4: v1(19.94,81.92) 19.84,81.82 19.84,80.99 19.01,80.15 11.67,80.15 9.49,82.33 9.49,84.94 v1(9.27,85.17)
N497403: length 2.7
  TOP w0.254: 18.92,79.76 19.32,79.36 U5.8
  TOP w0.4: 18.92,79.76 R8.2
N507782: length 2.2
  TOP w0.152: U5.17 14.95,74.41 R28.1
N507786: length 2
  TOP w0.152: U5.16 14.3,74.91 R26.1
N508362: length 22
  TOP w0.152: U9.13 v1(8.51,66.96) ; U9.4 5.33,65.66 v1(5.59,65.91) ; U4.6 2.16,78.46 R16.2 2.13,77.12 v1(3.17,76.07)
  BOTTOM w0.152: v1(3.17,76.07) 3.81,75.44 3.81,67.69 v1(5.59,65.91) 7.46,65.91 v1(8.51,66.96)
N508615: length 17
  TOP w0.152: v1(8,73.15) 9.65,73.15 U7.13 ; v1(5.33,80.26) 5.19,80.41 U4.3 2.15,80.41 R11.1 ; U7.10 8.58,71.23 v1(8.3,70.95)
  BOTTOM w0.152: v1(5.33,80.26) 5.33,75.82 v1(8,73.15) 8.3,72.86 v1(8.3,70.95)
N509670: length 1.9
  TOP w0.152: R15.1 U4.11
N509674: length 1.9
  TOP w0.152: R19.1 9.6,77.85 U4.8
N511498: length 14.9
  TOP w0.152: U7.1 5.03,73.83 6.73,72.14 6.73,65.66 5.43,64.36 2.29,64.36 R49.1
N512182: length 15.6
  TOP w0.152: U9.12 8.37,66.31 8,66.67 8,68.83 v1(8.13,68.96) 8.13,69.09 8.97,69.93 U7.8 ; R29.1 2.27,72.53 U7.3 5.64,72.53 6.22,71.95 6.22,69.34 v1(5.97,69.09)
  BOTTOM w0.152: v1(5.97,69.09) 8,69.09 v1(8.13,68.96)
N512199: length 5
  TOP w0.152: R25.1 6.83,73.56 7.86,72.53 U7.12
N517852: length 1.8
  TOP w0.152: 9.68,64.36 9.71,64.39 R50.1
N517913: length 1.7
  TOP w0.152: D2.2 R4.1
N518669: length 2
  TOP w0.152: R52.1 10.87,63.71 U9.8
N519131: length 1.8
  TOP w0.152: U7.5 2.27,71.23 R33.1
N519138: length 1.8
  TOP w0.152: R45.1 2.29,66.96 U9.2
N532592: length 7.1
  TOP w0.152: J7.3 25.16,59.04 U12.3 25.44,59.86 26.04,60.45 26.51,60.45 R286.2
N532639: length 1.4
  TOP w0.152: R53.1 25.22,62 U12.4
N533262: length 1.7
  TOP w0.152: U11.3 20.97,58.15 R56.2
N553084: length 5
  TOP w0.152: R124.2 44.38,7.58 SW2.2
N553120: length 2.6
  TOP w0.152: R116.2 SW3.2
N553666: length 5
  TOP w0.152: R1.2 55.08,88 SW1.1
N555301: length 1.5
  TOP w0.152: D1.2 44.01,87 R3.1
N555325: length 1.4
  TOP w0.152: Q1.3 47.03,88.37 R3.2
N555403: length 2.8
  TOP w0.254: R127.1 25.57,2.69 D7.2
N555427: length 2.8
  TOP w0.254: D5.2 14.8,5.44 R125.1
N555431: length 2.8
  TOP w0.254: D6.2 19.37,5.44 R126.1
N555483: length 2.1
  TOP w0.152: Q5.3 24.52,6.87 23.96,6.31 R127.2
N555487: length 1.7
  TOP w0.152: Q4.3 20.99,6.2 R126.2
N555495: length 1.7
  TOP w0.152: R125.2 16.42,6.07 Q3.3
N555589: length 1.1
  TOP w0.152: Q3.1 R119.2
N555601: length 1.1
  TOP w0.152: R121.2 Q4.1
N555605: length 1.1
  TOP w0.152: R123.2 25.91,8.94 Q5.1

## Copper pours and planes (outline as drawn)
GND on TOP: 0.51,91.31 2.67,93.47 54.48,93.47 57.91,90.04 57.91,8.13 57.91,3.17 55.24,0.51 3.68,0.51 0.51,3.68 ; 38 cut-outs
GND on BOTTOM: 0.51,91.31 2.67,93.47 54.48,93.47 57.91,90.04 57.91,8.13 57.91,3.17 55.24,0.51 3.68,0.51 0.51,3.68 ; 32 cut-outs
GND on GND: 0.51,91.31 2.67,93.47 54.48,93.47 57.91,90.04 57.91,8.13 57.91,3.17 55.24,0.51 3.68,0.51 0.51,3.68 ; 5 cut-outs
GND on PWR: 1.52,0.64 0.51,1.65 0.51,51.18 0.76,51.44 3.81,51.44 3.81,51.05 3.68,50.93 3.68,43.43 4.32,42.8 10.29,42.8 10.29,28.7 11.56,27.43 11.94,27.43 12.95,28.45 12.95,28.83 19.68,28.83 21.97,31.11 21.97,38.23 23.24,39.5 29.46,39.5 29.97,38.99 29.97,29.84 28.19,28.07 26.04,28.07 25.53,27.56 25.53,26.29 25.91,25.91 25.91,24.77 27.56,23.11 37.59,23.11 38.67,24.19 38.67,29.15 39.37,29.84 42.29,29.84 42.55,29.59 42.55,28.19 42.93,27.81 46.48,27.81 46.74,28.07 46.74,38.61 46.23,39.12 46.23,48.13 46.86,48.77 57.53,48.77 57.78,48.51 57.78,1.14 57.28,0.64 ; 4 cut-outs
VBAT_CC on TOP: 30.73,51.31 30.73,49.28 30.99,49.02 40.64,49.02 41.53,49.91 41.53,51.31 41.27,51.56 30.99,51.56
VBAT_CC on PWR: 29.26,51.56 19.18,51.56 17.91,50.29 17.91,42.29 14.48,38.86 14.48,30.48 14.99,29.97 14.99,29.46 15.37,29.08 18.8,29.08 21.84,32.13 21.84,38.73 23.24,40.13 30.23,40.13 32.13,42.04 33.02,42.04 33.66,41.4 33.66,40.39 33.02,39.75 33.02,31.75 33.53,31.24 35.31,31.24 35.56,31.5 35.56,51.05 35.18,51.44 33.83,51.44 33.05,52.22 33.05,53.99 33.71,54.65 33.71,64.69 48.97,79.96 48.97,82.58 48.74,82.8 46.99,82.8 46.35,82.17 46.35,79.71 43.23,76.58 40.82,76.58 32.26,68.02 32.26,56.13 30.2,54.08 30.2,53.98 29.26,53.04
VBUS_USB1 on TOP: 33.86,83.62 34.11,83.87 35.99,83.87 36.25,83.62 36.25,82.96 36.35,82.85 38.15,82.85 38.25,82.96 38.25,85.19 38.15,85.29 37.59,85.29 37.34,85.55 37.34,87.88 37.21,88.01 35.69,88.01 35.05,87.38 32,87.38 31.75,87.12 31.75,84.45 32.59,83.62
VBUS_USB1 on BOTTOM: 35.94,85.72 32.26,85.72 28.7,82.17 28.7,78.74 27.69,77.72 22.35,77.72 21.08,76.45 21.08,73.15 22.1,72.14 26.92,72.14 31.94,77.15 31.94,80.2 34.8,83.06 35.56,83.06 36.32,83.82 36.32,85.34
VCC_BRD on TOP: 30.99,53.98 30.99,52.32 35.18,52.32 35.43,52.58 35.43,53.98 35.05,54.36 31.37,54.36
VCC_BRD on PWR: 0.51,52.32 0.51,61.98 1.14,62.61 24,62.61 25.62,64.23 28.67,64.23 29.46,65.02 29.46,72.14 29.21,72.39 29.21,75.18 29.46,75.44 29.46,76.33 30.99,77.85 36.45,77.85 36.83,78.23 36.83,93.22 36.96,93.34 55.24,93.34 57.91,90.68 57.91,49.4 57.77,49.26 40.39,49.26 40.38,49.27 36.2,49.27 36.07,49.4 36.07,51.44 35.18,52.32 14.63,52.32 10.68,48.38 10.68,43.83 10.29,43.43 4.57,43.43 4.19,43.81 4.19,51.69 3.94,51.94 0.89,51.94
VCC_LDO_3V3 on PWR: 25.4,64.77 28.32,64.77 28.96,65.41 28.96,72.01 28.7,72.26 28.7,75.31 28.96,75.56 28.96,76.58 30.73,78.36 36.07,78.36 36.32,78.61 36.32,86.11 35.43,87 1.65,87 0.64,85.98 0.64,63.37 0.89,63.12 23.75,63.12
VDD_ANA on PWR: 38.1,27.94 37.85,28.19 36.32,28.19 34.8,26.67 33.02,26.67 32.77,26.92 32.77,29.46 33.27,29.97 33.27,30.73 32.51,31.5 32.51,40.01 33.15,40.64 33.15,41.15 32.77,41.53 32.38,41.53 30.48,39.62 30.48,29.72 28.32,27.56 26.29,27.56 26.16,27.43 26.16,26.42 26.42,26.16 26.42,25.02 27.81,23.62 36.45,23.62 38.1,25.27
VDD_PA on TOP: 34.42,29.59 33.27,29.59 33.15,29.46 33.15,27.69 33.4,27.43 34.16,27.43 34.54,27.81 34.54,29.46
VDD_PA on PWR: 42.55,48.39 42.16,48.77 36.2,48.77 36.07,48.64 36.07,31.11 35.69,30.73 33.91,30.73 33.78,30.61 33.78,29.72 33.27,29.21 33.27,27.43 33.53,27.18 34.54,27.18 36.32,28.96 37.72,28.96 39.24,30.48 41.91,30.48 42.55,31.11
N490588 on TOP: 11.2,86.33 12.22,86.33 12.37,86.49 12.37,88.42 11.51,89.28 11.51,90.5 11.43,90.58 10.95,90.58 10.87,90.5 10.87,89.03 11.07,88.82 11.07,86.46

## Text on the board
Ref Des/Silkscreen Bottom: VCC | P58 | P04 | P03 | P61 | P59 | P05 | P62 | P01 | P02 | 5V | P57 | P60 | GND | P63 | P53 | P50 | P64 | P17 | P29 | P16 | P30 | P07 | P06 | RST | P21 | P55 | P15 | P18 | P08 | P45 | P1 | P3 | P4 | P2 | Model: CC3200-LAUNCHXLA | FCC ID: Z64-CC3200KITA | IC ID: 451I-CC3200KITA
User.Comments: UNLESS OTHERWISE SPECIFIED | ALL DIMENSIONS ARE IN | INCHES | MILLIMETERS | REV C | JUNE 24 2014 | DATE | PART NUMBER: | CC3200LP 4.1 | A | FABRICATION DRAWING | TEXAS INSTRUMENTS | X
Ref Des/Silkscreen Top: P58 | P04 | P03 | P61 | P59 | P05 | P62 | P01 | P02 | DBGENn | GND | VCC | 5V | P4(GP13) | P30(G27) | P29(G26) | MAC | NWP | TCK | TMS | P63 | J1 | P60 | P53 | P57 | P50 | P64 | TDI | TDO | RX | TX | PWR | 3.3V | CC | FOR P21->BP | SHORT J14 | P15(GP22) | EMU | BRD | P29 | P30 | P17 | P21 | P18 | P16 | SDA | INT | SCL | 001:2W SWD | 000:4W JTAG | 100:FLASH | J15 | J16 | J17 | P08 | P45 | RST | P06 | P07 | P55 | P15 | P2(GP11) | FLASH | BP | P1(GP10) | P64(GP09) | SOP | P1 | P3 | Rev 4.1 | SENSORS | P4 | 2 | RESET | P2 | 1 | 2XAA | 0 | * | CC3200-LAUNCHXL | LAUNCHPAD
PAGE_OUTLINE: CAD | DATA | DO NOT MANUALLY | UPDATE | D | C | B | A | 8 | 7 | 6 | 5 | 4 | 3 | 2 | 1
DISPLAY_TOP: NOTES: UNLESS OTHERWISE SPECIFIED. | 9. MINIMUM CONDUCTOR WIDTH:4.0 MILS | REQUIREMENTS. | COPPER: AS PER STACKUP. | DIELECTRIC: FR4 | U.L. RATING: 94V-0 MINIMUM | 11.12MIL VIAS ARE TENTED IN BOTH THE MASK LAYER. | 1. FABRICATE PER IPC-6012A CLASS 2. | 2. SURFACE FINISH:  ENIG | 5. 100% CONTINUITY TESTING USING DATABASE NETLIST SHALL BE PERFORMED, | VENDOR TO IDENTIFY TEST PASSED IN SECONDARY  SIDE. | 3. SOLDER MASK MATERIAL SHALL MEET ALL THE REQUIREMENTS OF | IPC-SM-840C AND SHALL BE GREEN IN COLOR AND APPLIED OVER BARE COPPER. | 6. VENDOR TO MARK DATE CODE AND LOGO  IN ETCH OR IN LEGEND. | 10.SOLDER MASK CLEARANCE IS GIVEN SAME AS PAD SIZE EXCEPT NPTH AND FIDUCIALS. | 4. SILK SCREEN LEGEND TO BE APPLIED PER LAYER STACKUP USING WHITE | NON-CONDUCTIVE EPOXY INK. | 12.0.0121" VIAS ARE TO BE FILLED WITH NON-CONDUCTIVE EPOXY(VENDOR CHOICE) AND PLATED | 8. DIELECTRICS AND LINEWIDTHS MAY BE ADJUSTED TO MEET THE IMPEDANCE | 7. BOW AND TWIST SHALL NOT EXCEED 0.7% OF LONGEST SIDE . | VENDER SHALL MODIFY THE MASK CLEARANCE AS PER THE REQUIRED MANUFACTURING TOLERANCE. | +0.000"/-0.001" ON TOP SIDE AND +0.000"/-0.003" ON THE BOTTOM SIDE. | OVER WITH COPPER NICKEL AND GOLD. SURFACE MUST BE FLAT. FLATNESS TOLERANCE IS | MINIMUM SPACING:4.0 MILS
DIMENSION: ASSEMBLY PRIMARY SIDE
User.6: FABRICATION DRAWING | LAYER NO | 1 | CONDUCTOR WIDTH | 18.0 MIL | CONTROLLED IMPEDANCE USING CPW with GND | SPACING | 15 mil | IMPEDANCE +/- 10% | 50 OHMS | REFERENCE GND | L2
User.7: P2 | P4 | P3 | P1 | ASSEMBLY SECONDARY SIDE
User.8: 1.4 mm+/-10% | 4-LAYER STACK BUILD | SOLDER MASK(RED)------------->0.025 mm | SECONDARY SIDE, SILK SCREEN | LAYER 3                 ----->0.035 mm | DIELECTRIC              ----->0.255 mm | LAYER 4                 ----->0.035 mm | PRIMARY SIDE, SILK SCREEN | LAYER 1                 ----->0.035 mm | LAYER 2                 ----->0.035 mm | DIELECTRIC              ----->0.7   mm
User.15: DATE:JUNE 24 2014 | PART NO/CARD REF: | FILM LAYER: | CC3200LP 4.1 | JOB NUMBER:TS10114AC0 | DESIGNED BY: | COMPANY NAME : TEXAS INSTRUMENTS
User.16: LAYER 1 (TOP SIDE)
User.17: LAYER 2 (GND)
User.18: LAYER 3 (PWR)
User.21: LAYER 4(BOTTOM SIDE)
User.22: PRIMARY SIDE SILKSCREEN
User.23: SECONDARY SIDE  SILKSCREEN
User.24: PRIMARY SIDE PASTE LAYER
User.25: SECONDARY SIDE PASTE LAYER
User.26: PRIMARY SIDE SOLDERMASK
User.27: SECONDARY SIDE SOLDERMASK
User.28: OUTLINE
User.32: GENERAL NOTES-- UNLESS OTHERWISE SPECIFIED: | 1.   FABRICATE PER IPC-6012A CLASS 2 | 2.   SURFACE FINISH   :  ENIG | 3.   MATERIAL; FR4 | 5.   COPPER WT: 1 Oz | 6.   SOLDER MASK CLEARANCE IS GIVEN | 7. SOLDER MASK COLOUR : RED | SAME AS PAD SIZE EXCEPT FIDUCIAL | VENDOR SHALL MODIFY THE MASK CLEARANCE AS PER | THE REQUIRED MANUFACTURING TOLERANCE | SECTION A-A | NO SCALE
User.34: FIGURE | SIZE | 8.0 | 12.0 | 16.0 | 20.0 | 38.0 | 39.3701 | 98.4252 | 33.4646x21.6535 | 45.2756x19.685 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +0.0/-8.0 | +0.0/-12.0 | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 440 | 158 | 20 | 2 | 83 | 6 | 4
